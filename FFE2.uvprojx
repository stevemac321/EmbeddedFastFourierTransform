# Keil uVision project FFE2.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FFE2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: SAMPLE_SIZE=32
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./RTE/Device/STM32F401RETx/STCubeGenerated/Src/: graph.c pqueue.c
    ./RTE/Device/STM32F401RETx/STCubeGenerated/Inc/: graph.h
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F401RETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F401RETx/STCubeGenerated/Inc/: stm32f4xx_it.h
software components: CMSIS:CORE 6.1.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:ADC 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:Startup 2.6.3
